<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Lab4_Task2a.ewp</path>
    </project>
    <batchBuild />
</workspace>
